# Keil uVision project gesture.uvprojx, settings and files
target Gesture (ARM-ADS)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.2.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: gesture +hex
  AfterMake: fromelf.exe --bin -o build\gesture.bin build\gesture.axf
  c flags: Optim=4 wLevel=2
  c define: NDEBUG
  c misc: --no_rtti --no_rtti_data
  c include: .\CMSIS;.\mbed\api;.\mbed\hal;.\mbed\common;.\mbed\stm32f030f4
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  scatter file: .\CMSIS\TOOLCHAIN_ARM_MICRO\stm32f0xx.sct
  group CMSIS
    ./CMSIS/: cmsis_nvic.c stm32f0xx_hal.c stm32f0xx_hal_adc.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_cortex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_i2s.c stm32f0xx_hal_iwdg.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_rtc.c stm32f0xx_hal_rtc_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_usart.c stm32f0xx_hal_wwdg.c system_stm32f0xx.c stm32f0xx_hal_dma.c
    ./CMSIS/TOOLCHAIN_ARM_MICRO/: startup_stm32f030x4.s sys.cpp
  group src
    ./: gesture.c led.c uart.c gesture_it.c gesture_gpio.c
